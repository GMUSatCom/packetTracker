<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_burst_tagger</key>
<param><key>id</key><value>blocks_burst_tagger_0</value></param>
<param><key>false_key</key><value>burst</value></param>
<param><key>false_value</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>true_key</key><value>burst</value></param>
<param><key>true_value</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/aaron/Documents/satcom/ieeeTracker/testData/dataInPrime.m</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>5e6</value></param>
<param><key>calibr_bandw_ch0</key><value>5e6</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>30</value></param>
<param><key>nco_freq_ch0</key><value>915e6</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>nco_freq_ch1</key><value>915e6</value></param>
<param><key>channel_mode</key><value>2</value></param>
<param><key>serial</key><value>0009070105C62E09</value></param>
<param><key>filename</key><value>/home/aaron/Documents/satcom/limeSuite/testFiles/lms7suite_wfm/loraRadioDualChannel</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>915e6</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_burst_tagger_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>blocks_burst_tagger_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
